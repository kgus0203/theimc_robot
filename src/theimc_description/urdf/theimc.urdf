Commit message: Fix camera perception model path

File: src/theimc_description/urdf/theimc.urdf (robot description, URDF)
Before this commit: robot theimcbot_urdf, 8 links, 7 joints
Joints:
- joint lidar_joint: origin xyz=0.258 0 0.0725 rpy=0 0 0 -> xyz=0.258 0 0.1775 rpy=0 0 0
